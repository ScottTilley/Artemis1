options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Death by a thousand cuts...
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '20'
  states: {}
- name: offset_freq
  id: variable
  parameters:
    value: 2243.524e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sdr_freq
  id: variable
  parameters:
    value: 2242.6e6
  states: {}
- name: xlating_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 200e3
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: '.0314'
    min_freq: '.0157'
    w: '.05'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: test.dat
    type: byte
    vlen: '12'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '6000'
    type: byte
    vlen: '12'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset_freq-sdr_freq
    decim: decim
    samp_rate: samp_rate
    taps: xlating_taps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/decim
    fc: '0'
    fftsize: '32768'
    type: complex
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate/decim
    fc: '0'
    fftsize: '32768'
    type: complex
    ymin: '-120'
  states: {}
- name: satellites_phase_unwrap_0
  id: satellites_phase_unwrap
  parameters: {}
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 2e6
    center_freq0: sdr_freq
    clock_source0: external
    dev_args: name=MyB200,product=B200,serial=31C4F2E,type=b200,uhd
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_complex_to_arg_0, '0']
- [analog_pll_refout_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_arg_0, '0', satellites_phase_unwrap_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pll_refout_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [satellites_phase_unwrap_0, '0', blocks_keep_one_in_n_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
